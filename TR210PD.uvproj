# Keil uVision project TR210PD.uvproj, settings and files
target TR210PD (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: PileCore +hex
  link misc: REMOVEUNUSED
  group USER
    ./USER/: main.c
  group Hardware
    ./Hardware/Usart/: uart.c
    ./Hardware/LED/: led.c
    ./Hardware/TIM/: time.c
    ./Hardware/Eeprom/: EepRom.c
    ./Hardware/App/: epd_dose.c PDoseRateCalc.c pkur.c PdFilter.c
    ./ModBus/: ModBus.c ModBusDev.c
  group MwPro
    ./MwPro/: Cmd.c
